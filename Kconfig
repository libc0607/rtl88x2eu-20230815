## Kconfig
```kconfig
config RTL8822EU
	tristate "Realtek 8822E USB WiFi"
	depends on USB
	---help---
	  Help message of RTL8822EU
```
